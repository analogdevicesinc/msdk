# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX32650 Maxim MAX32650
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MXC_ASSERT_ENABLE
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Libraries\Boards\Include; ..\..\..\..\Libraries\Boards\QN_EvKit_V1\Include; ..\..\..\..\Libraries\CMSIS\Device\Maxim\MAX32650\Include; ..\..\..\..\Libraries\MAX32650PeriphDriver\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Maxim\MAX32650\MAX32650A.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group BSP
    ../../../../Libraries/Boards/QN_EvKit_V1/Source/: board.c
    ../../../../Libraries/Boards/Source/: led.c max14690.c nhd12832.c stdio.c
  group CMSIS
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32650/Source/IAR/: startup_max32650.s
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32650/Source/: system_max32650.c
  group HAL
    ../../../../Libraries/MAX32650PeriphDriver/Source/: clkman.c gpio.c i2cm.c ioman.c lp.c mxc_sys.c spim.c tmr.c tmr_utils.c uart.c
    ../../../../Libraries/Boards/Source/: pb.c
  group IAR
    ../../../../Libraries/CMSIS/Device/Maxim/MAX32650/Source/IAR/: cmain.s low_level_init.c
