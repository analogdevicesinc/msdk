# IAR project ADC.ewp, settings and files
configuration No Secure Boot (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32762; TARGET_REV=0X4131; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ADC.srec
  ILINK.IlinkOutputFile: ADC.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$\.iar\config\linker\MAX32672_WITHOUT_SIG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Secure Boot (ARM, debug)
  as the first configuration, except:
  postbuild: IAR_Signing_Tool\sign.bat $PROJ_DIR$ ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$\.iar\config\linker\MAX32672_WITH_SIG.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  postbuild: as above
  ILINK.IlinkIcfFile: as above
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/DMA/: dma_me21.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me21.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me21.c sys_me21.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me21.c gpio_reva.c
  group CMSIS-Pack/Maxim MAX32672 BSP _BSP.EvKit V1_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/Boards/MAX32672/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/Boards/MAX32672/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me21.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.4.1
    ../RTE/Device/MAX32672_Cortex-M4/: cmain.s low_level_init.c max32672.h sla_header.c startup_max32672.s system_max32672.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/ADC/: adc_me21.c adc_revb.c
