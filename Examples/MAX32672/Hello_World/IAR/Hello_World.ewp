# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32672; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$.iar\config\linker\MAX32670_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.7.0
    ../RTE/Device/MAX32672_Cortex-M4/: low_level_init.c startup_max32672.s low_level_init.c cmain.s max32672.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me21.c sys_me21.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me21.c adc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/AES/: aes_me21.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CTB_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/CTB/: ctb_me21.c ctb_reva.c ctb_common.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me21.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me21.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me21.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me21.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me21.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me21.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me21.c
  group CMSIS-Pack/Maxim Maxim API _Device.QDEC_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/QDEC/: qdec_me21.c qdec_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me21.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me21.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me21.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me21.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me21.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.7.0
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.7.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me21.c wdt_revb.c
