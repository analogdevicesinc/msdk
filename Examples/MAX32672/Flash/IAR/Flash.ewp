# IAR project Flash.ewp, settings and files
configuration No Secure Boot (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32762; TARGET_REV=0X4131; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Flash.srec
  ILINK.IlinkOutputFile: Flash.out
  ILINK.IlinkIcfFile: MAX32672_ram_flc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me21.c sys_me21.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/SPI/: spi_me21.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me21.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.4.1
    ../RTE/Device/MAX32672_Cortex-M4/: cmain.s low_level_init.c max32672.h sla_header.c startup_max32672.s system_max32672.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me21.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me21.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me21.c flc_reva.c
  group CMSIS-Pack/Maxim MAX32672 BSP _BSP.EvKit V1_1.4.1
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/Boards/MAX32672/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32672#1.4.1}$/Libraries/Boards/MAX32672/Source/: led.c pb.c stdio.c
