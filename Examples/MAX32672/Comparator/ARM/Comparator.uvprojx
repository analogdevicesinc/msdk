# Keil uVision project Comparator.uvprojx, settings and files
target Flash Debug (6160000::V6.16::ARMCLANG)
  device: MAX32672:Cortex-M4 Maxim
  pack: Maxim.MAX32672.1.4.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Comparator +hex
  AfterMake: $P\Keil_Signing_Tool\sign.bat $P $K $S
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32672 TARGET_REV=0x4131
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0xfffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\Comparator_Sig.sct
  link misc: --verbose --list=out.txt
  group Source
    ../: main.c
    ./: Abstract.txt
target Secure Boot (6160000::V6.16::ARMCLANG)
  device: MAX32672:Cortex-M4 Maxim
  pack: Maxim.MAX32672.1.4.1
  cpu: as above
  output: Comparator +hex
  AfterMake: $P\Keil_Signing_Tool\sign.bat $P $K $S
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32672 TARGET_REV=0x4131
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0xfffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\Comparator_Sig.sct
  link misc: --verbose --list=out.txt
target No Secure Boot (6160000::V6.16::ARMCLANG)
  device: MAX32672:Cortex-M4 Maxim
  pack: Maxim.MAX32672.1.4.1
  cpu: as above
  output: Comparator +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32672 TARGET_REV=0x4131 NO_SECURE_BOOT
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0xfffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\Comparator.sct
  link misc: --verbose --list=out.txt
software components: CMSIS:CORE 5.3.0, CMSIS:CORE 5.5.0, BSP:EvKit V1 1.4.1, Device:ADC 1.4.1, Device:DMA 1.4.1, Device:FLC 1.4.1, Device:GPIO 1.4.1, Device:Low Power 1.4.1, Device:SYS 1.4.1, Device:Startup 1.4.1, Device:UART 1.4.1
