# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=78000; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$.iar\config\linker\MAX78000_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.3.0
    ../RTE/Device/MAX78000_Cortex-M4/: low_level_init.c startup_max78000.s low_level_init.c cmain.s max78000.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_ai85.c sys_ai85.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me17.c adc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/AES/: aes_me17.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CAMERAIF_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/CAMERAIF/: cameraif_ai85.c cameraif_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CRC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/CRC/: crc_me17.c crc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me17.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me17.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_ai85.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me17.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_ai85.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me17.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/LP/: lp_ai85.c
  group CMSIS-Pack/Maxim Maxim API _Device.LPCMP_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/LPCMP/: lpcmp_ai85.c lpcmp_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_me17.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/PT/: pt_ai85.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me17.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SEMA_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/SEMA/: sema_me17.c sema_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me17.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_ai85.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_ai85.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/UART/: uart_ai85.c uart_common.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me17.c wdt_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX78000#1.3.0}$/Libraries/PeriphDrivers/Source/WUT/: wut_ai85.c wut_reva.c
