# IAR project SPI.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: SPI.srec
  ILINK.IlinkOutputFile: SPI.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$\.iar\config\linker\MAX32670_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32670 BSP _BSP.EvKit V1_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Boards/Maxim/MAX32670_EVKIT/Common/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Boards/Maxim/MAX32670_EVKIT/Common/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me15.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me15.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me15.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.0
    ../RTE/Device/MAX32670_Cortex-M4/: cmain.s low_level_init.c max32670.h startup_max32670.s system_max32670.c
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me15.c sys_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.0.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me15.c uart_revb.c
