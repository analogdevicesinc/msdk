# Keil uVision project AES.uvprojx, settings and files
target Flash Debug (6160000::V6.16::ARMCLANG)
  device: MAX32675:Cortex-M4 Maxim
  pack: Maxim.MAX32675.1.0.3
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: AES +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32675 TARGET_REV=0x4131
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\AES.sct
  link misc: --verbose --list=out.txt
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.3, Device:AES 1.0.3, Device:AFE 1.0.3, Device:DMA 1.0.3, Device:FLC 1.0.3, Device:GPIO 1.0.3, Device:SPI 1.0.3, Device:SYS 1.0.3, Device:Startup 1.0.3, Device:TRNG 1.0.3, Device:Timers 1.0.3, Device:UART 1.0.3
