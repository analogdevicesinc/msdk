# IAR project AES.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET_REV=0x4131; TARGET=32675; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: AES.srec
  ILINK.IlinkOutputFile: AES.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$\.iar\config\linker\MAX32675_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me16.c sys_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me16.c gpio_reva.c
  group CMSIS-Pack/Maxim MAX32675 BSP _BSP.EvKit V1_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/Boards/MAX32675/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/Boards/MAX32675/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me16.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me15.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.3
    ../RTE/Device/MAX32675_Cortex-M4/: cmain.s low_level_init.c max32675.h startup_max32675.s system_max32675.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/AES/: aes_me15.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/DMA/: dma_me15.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.AFE_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/AFE/: afe.c afe_gpio.c hart_uart.c infoblock.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me15.c flc_reva.c flc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.0.3
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.0.3}$/Libraries/PeriphDrivers/Source/SPI/: spi_me15.c spi_reva.c
