# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32675; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$.iar\config\linker\MAX32675_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.5.0
    ../RTE/Device/MAX32675_Cortex-M4/: low_level_init.c startup_max32675.s low_level_init.c cmain.s max32675.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me16.c sys_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/AES/: aes_me15.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.AFE_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/AFE/: afe.c afe_gpio.c afe_timer.c hart_uart.c infoblock.c
  group CMSIS-Pack/Maxim Maxim API _Device.CRC_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/CRC/: crc_me15.c crc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me15.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me15.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me16.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me15.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me15.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me15.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me15.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me15.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me16.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me16.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.5.0
    ${CMSIS_PACK_PATH_Maxim#MAX32675#1.5.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me15.c wdt_revb.c
