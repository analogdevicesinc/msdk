# Keil uVision project Watchdog.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32670:Cortex-M4 Maxim
  pack: Maxim.MAX32670.1.0.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Watchdog +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress 1295 --diag_suppress 111
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\Watchdog.sct
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.0, Device:DMA 1.0.0, Device:GPIO 1.0.0, Device:Low Power 1.0.0, Device:Startup 1.0.0, Device:Timers 1.0.0, Device:UART 1.0.0, Device:WDT 1.0.0, Target Rev:None 1.0.0
