# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=78002; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$.iar\config\linker\MAX78002_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.2.0
    ../RTE/Device/MAX78002_Cortex-M4/: low_level_init.c startup_max78002.s low_level_init.c cmain.s max78002.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_ai87.c sys_ai87.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_ai87.c adc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/AES/: aes_ai87.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CAMERAIF_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/CAMERAIF/: cameraif_ai87.c cameraif_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CRC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/CRC/: crc_ai87.c crc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CSI2_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/CSI2/: csi2_ai87.c csi2_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_ai87.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_ai87.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_ai87.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_ai87.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_ai87.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_ai87.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/LP/: lp_ai87.c
  group CMSIS-Pack/Maxim Maxim API _Device.LPCMP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/LPCMP/: lpcmp_ai87.c lpcmp_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_ai87.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/PT/: pt_ai87.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_ai87.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SDHC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/SDHC/: sdhc_ai87.c sdhc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_ai87.c spi_reva1.c spi_ai87_v2.c spi_reva2.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_ai87.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_ai87.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/UART/: uart_ai87.c uart_common.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_ai87.c wdt_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX78002#1.2.0}$/Libraries/PeriphDrivers/Source/WUT/: wut_ai87.c wut_reva.c
