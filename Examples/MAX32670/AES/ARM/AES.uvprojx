# Keil uVision project AES.uvprojx, settings and files
target Flash Debug (6180000::V6.18::ARMCLANG)
  device: MAX32670:Cortex-M4 Maxim
  pack: Maxim.MAX32670.1.1.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: AES +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: TARGET=32670 TARGET_REV=0x4131
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x5ffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\AES.sct
  link misc: --verbose --list=out.txt
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:Board Type 1.1.0, BSP:LED 1.1.0, BSP:PMIC 1.1.0, BSP:Push Btn 1.1.0, Device:AES 1.1.0, Device:DMA 1.1.0, Device:FLC 1.1.0, Device:GPIO 1.1.0, Device:I2C 1.1.0, Device:Startup 1.1.0, Device:TRNG 1.1.0, Device:Timers 1.1.0, Device:UART 1.1.0
