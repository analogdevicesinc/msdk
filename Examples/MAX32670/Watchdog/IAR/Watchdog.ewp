# IAR project Watchdog.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32670; TARGET_REV=0X4131; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Watchdog.srec
  ILINK.IlinkOutputFile: Watchdog.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$\.iar\config\linker\MAX32670_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32670 BSP _BSP.Board Type.EvKit_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/Boards/MAX32670/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/MiscDrivers/: stdio.c
  group CMSIS-Pack/Maxim MAX32670 BSP _BSP.LED_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/MiscDrivers/LED/: led.c
  group CMSIS-Pack/Maxim MAX32670 BSP _BSP.PMIC_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/MiscDrivers/PMIC/: max20303.c
  group CMSIS-Pack/Maxim MAX32670 BSP _BSP.Push Btn_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/MiscDrivers/PushButton/: pb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Low Power_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me15.c wdt_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me15.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me15.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.1.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me15.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.1.0
    ../RTE/Device/MAX32670_Cortex-M4/: cmain.s low_level_init.c max32670.h startup_max32670.s system_max32670.c
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.1.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me15.c sys_me15.c
