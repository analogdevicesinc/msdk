# Keil uVision project SecureROM_BL_Host.uvprojx, settings and files
target Flash Debug (6160000::V6.16::ARMCLANG)
  device: MAX32670:Cortex-M4 Maxim
  pack: Maxim.MAX32670.1.2.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: SecureROM_BL_Host +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32670 TARGET_REV=0x4131 EXT_FLASH_MX25
  c include: ..\..\SecureROM_BL_Host;\ARM;\bootloader;\include;\test_images
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\SecureROM_BL_Host.sct
  group Source
    ../bootloader/: bootloader.c
    ../src/: main.c platform_max32670.c terminal.c
    ../test_images/MAX32520-KIT/: blinkled_P1_6.c blinkled_P1_7.c
    ../test_images/MAX32651-EVKIT/: blinkled_P2_25.c
software components: CMSIS:CORE 5.3.0, BSP:Board Type 1.2.0, BSP:LED 1.2.0, BSP:PMIC 1.2.0, BSP:PushButton 1.2.0, Device:Startup 1.2.0, Device:SYS 1.2.0, Device:AES 1.2.0, Device:CRC 1.2.0, Device:DMA 1.2.0, Device:FLC 1.2.0, Device:GPIO 1.2.0, Device:I2C 1.2.0, Device:I2S 1.2.0, Device:ICC 1.2.0, Device:LP 1.2.0, Device:RTC 1.2.0, Device:SPI 1.2.0, Device:TRNG 1.2.0, Device:TMR 1.2.0, Device:UART 1.2.0, Device:WDT 1.2.0
