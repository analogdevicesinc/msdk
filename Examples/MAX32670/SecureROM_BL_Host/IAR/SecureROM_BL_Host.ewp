# IAR project SecureROM_BL_Host.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32670; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE; ..\bootloader; ..\include; ..\test_images
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  OBJCOPY.OOCOutputFile: SecureROM_BL_Host.srec
  ILINK.IlinkOutputFile: SecureROM_BL_Host.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$.iar\config\linker\MAX32670_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ../bootloader/: bootloader.c
    ../src/: main.c platform_max32670.c terminal.c
    ../test_images/MAX32520-KIT/: blinkled_P1_6.c blinkled_P1_7.c
    ../test_images/MAX32651-EVKIT/: blinkled_P2_25.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.2.0
    ../RTE/Device/MAX32670_Cortex-M4/: low_level_init.c startup_max32670.s low_level_init.c cmain.s max32670.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me15.c sys_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/AES/: aes_me15.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CRC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/CRC/: crc_me15.c crc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me15.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me15.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me15.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me15.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me15.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me15.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me15.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me15.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me15.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me15.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me15.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me15.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32670#1.2.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me15.c wdt_revb.c
