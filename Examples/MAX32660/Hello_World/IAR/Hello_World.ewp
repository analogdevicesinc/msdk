# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32660; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$.iar\config\linker\MAX32660_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32660 BSP _BSP.ExtMemory.MX25_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group CMSIS-Pack/Maxim MAX32660 BSP _BSP.Board Type.EvKit_V1_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/Boards/MAX32660/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/MiscDrivers/: stdio.c
  group CMSIS-Pack/Maxim MAX32660 BSP _BSP.LED.LED_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/MiscDrivers/LED/: led.c
  group CMSIS-Pack/Maxim MAX32660 BSP _BSP.PushButton.PB_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/MiscDrivers/PushButton/: pb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me11.c wdt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me11.c uart_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me11.c tmr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIMSS_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/SPIMSS/: i2s_me11.c i2s_reva.c spimss_me11.c spimss_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me11.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me11.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me11.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me11.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me11.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me11.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me11.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me11.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.6.0
    ${CMSIS_PACK_PATH_Maxim#MAX32660#1.6.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me11.c sys_me11.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.6.0
    ../RTE/Device/MAX32660_Cortex-M4/: cmain.s low_level_init.c max32660.h startup_max32660.s system_max32660.c
