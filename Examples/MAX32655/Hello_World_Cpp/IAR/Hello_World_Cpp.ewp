# IAR project Hello_World_Cpp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32655; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World_Cpp.srec
  ILINK.IlinkOutputFile: Hello_World_Cpp.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$.iar\config\linker\MAX32655_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.2.0
    ../RTE/Device/MAX32655_Cortex-M4/: low_level_init.c startup_max32655.s low_level_init.c cmain.s max32655.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me17.c sys_me17.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me17.c adc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.AES_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/AES/: aes_me17.c aes_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CRC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/CRC/: crc_me17.c crc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me17.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me17.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me17.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me17.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me17.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me17.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me17.c
  group CMSIS-Pack/Maxim Maxim API _Device.LPCMP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/LPCMP/: lpcmp_me17.c lpcmp_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_me17.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/PT/: pt_me17.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me17.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SEMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/SEMA/: sema_me17.c sema_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SIMO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/SIMO/: simo_me17.c simo_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me17.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me17.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me17.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me17.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me17.c wdt_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.2.0}$/Libraries/PeriphDrivers/Source/WUT/: wut_me17.c wut_reva.c
