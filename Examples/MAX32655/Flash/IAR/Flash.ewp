# IAR project Flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32655; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Flash.srec
  ILINK.IlinkOutputFile: Flash.out
  ILINK.IlinkIcfFile: MAX32655_ram_flc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.Board Type.EvKit_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/: stdio.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.Display.TFT_SSD2119_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/Display/: tft_ssd2119.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.ExtMemory.MX25_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.LED_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/LED/: led.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.PMIC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/PMIC/: max20303.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.Push Btn_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/PushButton/: pb.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.Touch Screen.TSC2046_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/MiscDrivers/Touchscreen/: tsc2046.c
  group CMSIS-Pack/Maxim Maxim API _Device.SIMO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SIMO/: simo_me17.c simo_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me17.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me17.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me17.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me17.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.0
    ../RTE/Device/MAX32655_Cortex-M4/: cmain.s low_level_init.c max32655.h startup_max32655.s system_max32655.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me17.c sys_me17.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me17.c uart_revb.c
