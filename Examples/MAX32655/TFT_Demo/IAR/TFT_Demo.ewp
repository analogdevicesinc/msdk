# IAR project TFT_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32655; TARGET_REV=0x4131; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe188, Pe144, Pe111, Pe167, Pe186, Pe068, Pa082
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE; ..\include; ..\resources
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  OBJCOPY.OOCOutputFile: TFT_Demo.srec
  ILINK.IlinkOutputFile: TFT_Demo.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$.iar\config\linker\MAX32655_IAR_TFT_3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../resources/: all_imgs.c
    ../: arm_tft.c main.c
    ../src/: state.c state_home.c state_info.c state_keypad.c utils.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me17.c icc_reva.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.EvKit V1_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me17.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me17.c flc_reva.c flc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me17.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me17.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.0
    RTE/Device/MAX32655_Cortex-M4/: cmain.s low_level_init.c max32655.h startup_max32655.s system_max32655.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me17.c sys_me17.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me17.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me17.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me17.c adc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TFT_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/Source/: tft.c touchscreen.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me17.c rtc_reva.c
