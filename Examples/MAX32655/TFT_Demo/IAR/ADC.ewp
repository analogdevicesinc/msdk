# IAR project ADC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe188, Pe144, Pe111, Pe167, Pe186, Pe068, Pa082
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: TFT_DEMO.srec
  ILINK.IlinkOutputFile: TFT_DEMO.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$.iar\config\linker\MAX32655_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me17.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me17.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.0
    ../RTE/Device/MAX32655_Cortex-M4/: cmain.s low_level_init.c max32655.h startup_max32655.s system_max32655.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me17.c sys_me17.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me17.c spi_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me17.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me17.c flc_reva.c flc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me17.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TFT_DEMO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/PeriphDrivers/Source/TFT_DEMO/: TFT_DEMO_common.c TFT_DEMO_me17.c TFT_DEMO_reva.c
  group CMSIS-Pack/Maxim MAX32655 BSP _BSP.EvKit V1_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32655#1.0.0}$/Libraries/Boards/MAX32655/Source/: led.c pb.c stdio.c
