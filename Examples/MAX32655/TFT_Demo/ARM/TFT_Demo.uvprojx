# Keil uVision project TFT_Demo.uvprojx, settings and files
target Flash Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32655:Cortex-M4 Maxim
  pack: Maxim.MAX32655.1.0.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: TFT_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32670 TARGET_REV=0x4131
  c misc: --diag_suppress 1295 --diag_suppress 111
  c include: ..\include;..\resources;..\..\TFT_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\TFT_DEMO.sct
  link misc: --verbose --list=out.txt --keep=all_imgs.o
  group Source
    ../: main.c arm_tft.c
    ./: Abstract.txt
    ../resources/: all_imgs.c
    ../src/: state.c state_home.c state_info.c state_keypad.c utils.c
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.0, Device:AES 1.0.0, Device:DMA 1.0.0, Device:FLC 1.0.0, Device:GPIO 1.0.0, Device:ICC 1.0.0, Device:RTC 1.0.0, Device:SPI 1.0.0, Device:SYS 1.0.0, Device:Startup 1.0.0, Device:TFT 1.0.0, Device:TRNG 1.0.0, Device:UART 1.0.0
