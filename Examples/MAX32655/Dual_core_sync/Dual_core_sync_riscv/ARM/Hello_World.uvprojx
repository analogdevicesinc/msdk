# Keil uVision project Hello_World.uvprojx, settings and files
target Flash Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MAX32655:Cortex-M4 Maxim
  pack: Maxim.MAX32655.1.0.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Dual_core_sync_riscv +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32655 TARGET_REV=0x4131
  c misc: --diag_suppress 1295 --diag_suppress 111
  c include: ..\..\Dual_core_sync_riscv
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Dual_core_sync_riscv.sct
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.0, Device:AES 1.0.0, Device:DMA 1.0.0, Device:FLC 1.0.0, Device:GPIO 1.0.0, Device:ICC 1.0.0, Device:SYS 1.0.0, Device:Startup 1.0.0, Device:TRNG 1.0.0, Device:Timers 1.0.0, Device:UART 1.0.0
