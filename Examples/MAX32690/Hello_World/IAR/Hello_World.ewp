# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32690; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$.iar\config\linker\MAX32690_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.4.0
    ../RTE/Device/MAX32690_Cortex-M4/: low_level_init.c startup_max32690.s low_level_init.c cmain.s max32690.h
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me18.c sys_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me18.c adc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CAN_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/CAN/: can_me18.c can_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CTB_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/CTB/: ctb_me18.c ctb_reva.c ctb_common.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me18.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.EMCC_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/EMCC/: emcc_me18.c emcc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me18.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me18.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.HPB_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/HPB/: hpb_me18.c hpb_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me18.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me18.c i2s_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me18.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.LPCMP_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/LPCMP/: lpcmp_me18.c lpcmp_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_me18.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/PT/: pt_me18.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me18.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SEMA_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/SEMA/: sema_me18.c sema_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me18.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXF_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/SPIXF/: spixf_me18.c spixf_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXR_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/SPIXR/: spixr_me18.c spixr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me18.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me18.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me18.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me18.c wdt_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.4.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.4.0}$/Libraries/PeriphDrivers/Source/WUT/: wut_me18.c wut_reva.c
