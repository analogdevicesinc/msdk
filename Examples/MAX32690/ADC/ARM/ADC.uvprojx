# Keil uVision project ADC.uvprojx, settings and files
target Flash Debug (6160000::V6.16::ARMCLANG)
  device: MAX32690:Cortex-M4 Maxim
  pack: Maxim.MAX32690.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: ADC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32690 TARGET_REV=0x4131
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0xfffff
  memory RVCT9: RAM 0x20000000 size 0x27fff
  scatter file: .\ADC.sct
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.3.0, BSP:EvKit V1 1.0.1, Device:ADC 1.0.1, Device:DMA 1.0.1, Device:GPIO 1.0.1, Device:SYS 1.0.1, Device:Startup 1.0.1, Device:TRNG 1.0.1, Device:Timers 1.0.1, Device:UART 1.0.1
