# IAR project BLE_datc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=MAX32690; TARGET_REV=0x4131; DEBUG; MXC_ASSERT_ENABLE; ATT_TRACE_ENABLED=0; HCI_TRACE_ENABLED=0; BT_VER=8; SCH_CHECK_LIST_INTEGRITY=1; uECC_ASM=2; INIT_BROADCASTER; INIT_PERIPHERAL; INIT_OBSERVER; INIT_CENTRAL; INIT_ENCRYPTED; WSF_BUF_FREE_CHECK_ASSERT=1; WSF_BUF_STATS=1; WSF_CS_STATS=1; WSF_ASSERT_ENABLED=1; WSF_TRACE_ENABLED=1; SEC_CMAC_CFG=1; SEC_ECC_CFG=2; SEC_CCM_CFG=1; HCI_TR_EXACTLE=1; WSF_BUF_STATS=1; WSF_ASSERT_ENABLED=1; WSF_TRACE_ENABLED=1; HCI_UART=0; TERMINAL_UART=2; USER_UART=1; BB_CLK_RATE_HZ=1000000; LCTR_CONN_NO_TIFS_REASSEMBLY=1; CHCI_TR_UART=1; UART_BAUD=115200; UART_HWFC=0; BB_ENABLE_INLINE_ENC_TX=1; BB_ENABLE_INLINE_DEC_RX=1; PAL_MAX_RTC_COUNTER_VAL=0xFFFFFFFF; PAL_SYS_ENABLE_STANDBY=0; LL_WW_RX_DEVIATION_USEC=0; BOARD=EvKit_V1; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCDiagSuppress: Pe188, Pe144, Pe111, Pe167, Pe186, Pe068, Pa082
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: BLE_datc.srec
  ILINK.IlinkOutputFile: BLE_datc.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$.iar\config\linker\MAX32690_IAR_BLE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: datc_main.c main.c stack_datc.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.ExtMemory_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXF_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/SPIXF/: spixf_me18.c spixf_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me18.c uart_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me18.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.1
    RTE/Device/MAX32690_Cortex-M4/: cmain.s heap.c low_level_init.c max32690.h startup_max32690.s system_max32690.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me18.c sys_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me18.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me18.c flc_reva.c flc_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/DMA/: dma_me18.c dma_reva.c
  group CMSIS-Pack/Maxim MAX32690 BSP _BSP.EvKit V1_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Boards/MAX32690/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Boards/MAX32690/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim BTLE _Bluetooth.Bluetooth LE_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/anpc/: anpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/af/common/: app_db.c app_hw.c app_ui.c ui_console.c ui_lcd.c ui_main.c ui_platform.c ui_timer.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/af/: app_disc.c app_main.c app_master.c app_master_ae.c app_master_leg.c app_server.c app_slave.c app_slave_ae.c app_slave_leg.c app_terminal.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/atpc/: atpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/atps/: atps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/att/: att_eatt.c att_main.c att_uuid.c attc_disc.c attc_eatt.c attc_main.c attc_proc.c attc_read.c attc_sign.c attc_write.c atts_ccc.c atts_csf.c atts_dyn.c atts_eatt.c atts_ind.c atts_main.c atts_proc.c atts_read.c atts_sign.c atts_write.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/bas/: bas_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/bb/: bb_ble_adv_master.c bb_ble_adv_master_ae.c bb_ble_adv_slave.c bb_ble_adv_slave_ae.c bb_ble_bis_master.c bb_ble_bis_slave.c bb_ble_cis.c bb_ble_cis_master.c bb_ble_cis_slave.c bb_ble_conn.c bb_ble_conn_master.c bb_ble_conn_slave.c bb_ble_dtm.c bb_ble_main.c bb_ble_pdufilt.c bb_ble_periodiclist.c bb_ble_reslist.c bb_ble_sniffer.c bb_ble_whitelist.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/common/bb/: bb_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/wsf/sources/util/: bda.c bstream.c calc128.c crc32.c fcs.c prand.c print.c terminal.c wstr.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/blpc/: blpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/blps/: blps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/cfg/: cfg_stack.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/common/chci/: chci_tr.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/cpp/: cpps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/cscp/: cscps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/dis/: dis_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/dm/: dm_adv.c dm_adv_ae.c dm_adv_leg.c dm_bis_master.c dm_bis_slave.c dm_cis.c dm_cis_master.c dm_cis_slave.c dm_cis_sm.c dm_conn.c dm_conn_cte.c dm_conn_master.c dm_conn_master_ae.c dm_conn_master_leg.c dm_conn_slave.c dm_conn_slave_ae.c dm_conn_slave_leg.c dm_conn_sm.c dm_dev.c dm_dev_priv.c dm_main.c dm_past.c dm_phy.c dm_priv.c dm_scan.c dm_scan_ae.c dm_scan_leg.c dm_sec.c dm_sec_lesc.c dm_sec_master.c dm_sec_slave.c dm_sync_ae.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/fmpl/: fmpl_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/gap/: gap_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/gatt/: gatt_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/glpc/: glpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/glps/: glps_db.c glps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/sensor/: gyro_main.c temp_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/hci/exactle/: hci_cmd.c hci_cmd_ae.c hci_cmd_bis.c hci_cmd_cis.c hci_cmd_cte.c hci_cmd_enc.c hci_cmd_master.c hci_cmd_master_ae.c hci_cmd_past.c hci_cmd_phy.c hci_core_ps.c hci_evt.c hci_vs.c hci_vs_ae.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/hci/common/: hci_core.c hci_tr.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/hci/: hci_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/hid/: hid_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-apps/sources/hidapp/: hidapp_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/hrpc/: hrpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/hrps/: hrps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/htpc/: htpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/htps/: htps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/init/: init.c init_ctr.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/l2c/: l2c_coc.c l2c_main.c l2c_master.c l2c_slave.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/lctr/: lctr_act_adv_master.c lctr_act_adv_master_ae.c lctr_act_adv_slave.c lctr_act_adv_slave_ae.c lctr_act_bis_master.c lctr_act_bis_slave.c lctr_act_cis.c lctr_act_cis_master.c lctr_act_cis_slave.c lctr_act_conn.c lctr_act_conn_master.c lctr_act_conn_master_ae.c lctr_act_conn_past.c lctr_act_enc.c lctr_act_enc_master.c lctr_act_init_master.c lctr_act_init_master_ae.c lctr_act_pc.c lctr_act_phy.c lctr_isr_adv_master.c lctr_isr_adv_master_ae.c lctr_isr_adv_slave.c lctr_isr_adv_slave_ae.c lctr_isr_bis_master.c lctr_isr_bis_slave.c lctr_isr_cis.c lctr_isr_cis_master.c lctr_isr_cis_slave.c lctr_isr_conn.c lctr_isr_conn_master.c lctr_isr_conn_slave.c lctr_isr_init_master.c lctr_isr_init_master_ae.c lctr_main.c lctr_main_adv_master.c lctr_main_adv_master_ae.c lctr_main_adv_slave.c lctr_main_adv_slave_ae.c lctr_main_bis.c lctr_main_bis_master.c lctr_main_bis_slave.c lctr_main_cis.c lctr_main_cis_master.c lctr_main_cis_slave.c lctr_main_conn.c lctr_main_conn_cs2.c lctr_main_conn_data.c lctr_main_conn_master.c lctr_main_conn_slave.c lctr_main_enc_master.c lctr_main_enc_slave.c lctr_main_init_master.c lctr_main_init_master_ae.c lctr_main_iso.c lctr_main_iso_data.c lctr_main_master_phy.c lctr_main_past.c lctr_main_pc.c lctr_main_priv.c lctr_main_sc.c lctr_main_slave_phy.c lctr_pdu_adv_master_ae.c lctr_pdu_adv_slave.c lctr_pdu_adv_slave_ae.c lctr_pdu_bis.c lctr_pdu_conn.c lctr_pdu_enc.c lctr_pdu_iso.c lctr_sm_adv_master.c lctr_sm_adv_master_ae.c lctr_sm_adv_slave.c lctr_sm_adv_slave_ae.c lctr_sm_bis_master.c lctr_sm_bis_slave.c lctr_sm_cis.c lctr_sm_conn_master.c lctr_sm_conn_slave.c lctr_sm_init_master.c lctr_sm_init_master_ae.c lctr_sm_llcp_cis.c lctr_sm_llcp_cis_master.c lctr_sm_llcp_cis_slave.c lctr_sm_llcp_conn.c lctr_sm_llcp_conn_master.c lctr_sm_llcp_conn_slave.c lctr_sm_llcp_enc_master.c lctr_sm_llcp_enc_slave.c lctr_sm_llcp_master_phy.c lctr_sm_llcp_pc.c lctr_sm_llcp_slave_phy.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/lhci/: lhci_cmd.c lhci_cmd_adv_master.c lhci_cmd_adv_master_ae.c lhci_cmd_adv_priv.c lhci_cmd_adv_slave.c lhci_cmd_adv_slave_ae.c lhci_cmd_bis_master.c lhci_cmd_bis_slave.c lhci_cmd_cis_master.c lhci_cmd_cis_slave.c lhci_cmd_conn.c lhci_cmd_conn_master.c lhci_cmd_conn_master_ae.c lhci_cmd_conn_priv.c lhci_cmd_enc_master.c lhci_cmd_enc_slave.c lhci_cmd_iso.c lhci_cmd_past.c lhci_cmd_pc.c lhci_cmd_phy.c lhci_cmd_sc.c lhci_cmd_vs.c lhci_cmd_vs_adv_master.c lhci_cmd_vs_adv_master_ae.c lhci_cmd_vs_adv_slave.c lhci_cmd_vs_adv_slave_ae.c lhci_cmd_vs_conn.c lhci_cmd_vs_conn_master.c lhci_cmd_vs_enc_slave.c lhci_cmd_vs_iso.c lhci_cmd_vs_sc.c lhci_evt.c lhci_evt_adv_master.c lhci_evt_adv_master_ae.c lhci_evt_adv_slave.c lhci_evt_adv_slave_ae.c lhci_evt_bis_master.c lhci_evt_bis_slave.c lhci_evt_cis_master.c lhci_evt_cis_slave.c lhci_evt_conn.c lhci_evt_conn_cs2.c lhci_evt_conn_master.c lhci_evt_conn_priv.c lhci_evt_enc_master.c lhci_evt_enc_slave.c lhci_evt_iso.c lhci_evt_pc.c lhci_evt_phy.c lhci_evt_sc.c lhci_evt_vs.c lhci_init.c lhci_init_adv_master.c lhci_init_adv_master_ae.c lhci_init_adv_priv.c lhci_init_adv_slave.c lhci_init_adv_slave_ae.c lhci_init_bis_master.c lhci_init_bis_slave.c lhci_init_cis_master.c lhci_init_cis_slave.c lhci_init_conn.c lhci_init_conn_cs2.c lhci_init_conn_master.c lhci_init_conn_master_ae.c lhci_init_conn_priv.c lhci_init_enc_master.c lhci_init_enc_slave.c lhci_init_iso.c lhci_init_past.c lhci_init_pc.c lhci_init_phy.c lhci_init_sc.c lhci_main.c lhci_main_iso.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/BlePhy/MAX32690/IAR/: libphy_iar.a
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/ll/: ll_init.c ll_init_adv_master.c ll_init_adv_master_ae.c ll_init_adv_slave.c ll_init_adv_slave_ae.c ll_init_bis_master.c ll_init_bis_slave.c ll_init_cis_master.c ll_init_cis_slave.c ll_init_conn_cs2.c ll_init_conn_master.c ll_init_conn_slave.c ll_init_enc_master.c ll_init_enc_slave.c ll_init_init_master.c ll_init_init_master_ae.c ll_init_iso.c ll_init_master_phy.c ll_init_past.c ll_init_pc.c ll_init_priv.c ll_init_sc.c ll_init_slave_phy.c ll_main.c ll_main_adv_master.c ll_main_adv_master_ae.c ll_main_adv_slave.c ll_main_adv_slave_ae.c ll_main_bis_master.c ll_main_bis_slave.c ll_main_cis_master.c ll_main_cis_slave.c ll_main_conn.c ll_main_conn_master.c ll_main_conn_master_ae.c ll_main_conn_slave.c ll_main_diag.c ll_main_dtm.c ll_main_enc_master.c ll_main_enc_slave.c ll_main_iso.c ll_main_past.c ll_main_pc.c ll_main_phy.c ll_main_priv.c ll_main_sc.c ll_math.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/lmgr/: lmgr_events.c lmgr_main.c lmgr_main_adv_master_ae.c lmgr_main_adv_slave_ae.c lmgr_main_cis_master.c lmgr_main_conn.c lmgr_main_iso.c lmgr_main_master.c lmgr_main_priv.c lmgr_main_sc.c lmgr_main_slave.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/platform/targets/maxim/max32690/sources/: pal_btn.c pal_cfg.c pal_codec.c pal_crypto.c pal_flash.c pal_i2s.c pal_led.c pal_rtc.c pal_sys.c pal_timer.c pal_twi.c pal_uart.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/paspc/: paspc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/plxpc/: plxpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/plxps/: plxps_db.c plxps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/rscp/: rscps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/ble/sch/: sch_ble.c sch_rm.c sch_tm.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/controller/sources/common/sch/: sch_list.c sch_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/scpps/: scpps_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/sec/common/: sec_aes.c sec_aes_rev.c sec_ccm_hci.c sec_cmac_hci.c sec_ecc_hci.c sec_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-host/sources/stack/smp/: smp_act.c smp_db.c smp_main.c smp_non.c smp_sc_act.c smp_sc_main.c smpi_act.c smpi_sc_act.c smpi_sc_sm.c smpi_sm.c smpr_act.c smpr_sc_act.c smpr_sc_sm.c smpr_sm.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/services/: svc_alert.c svc_batt.c svc_bps.c svc_core.c svc_cps.c svc_cscs.c svc_cte.c svc_dis.c svc_gls.c svc_gyro.c svc_hid.c svc_hrs.c svc_hts.c svc_ipss.c svc_plxs.c svc_px.c svc_rscs.c svc_scpss.c svc_temp.c svc_time.c svc_uricfg.c svc_wdxs.c svc_wp.c svc_wss.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/tipc/: tipc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/udsc/: udsc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/thirdparty/uecc/: uECC.c uECC_ll.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/uribeacon/: uricfg_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/wdxc/: wdxc_ft.c wdxc_main.c wdxc_stream.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/wdxs/: wdxs_au.c wdxs_dc.c wdxs_ft.c wdxs_main.c wdxs_phy.c wdxs_stream.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/wpc/: wpc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/wsf/sources/targets/baremetal/: wsf_assert.c wsf_buf.c wsf_bufio.c wsf_cs.c wsf_detoken.c wsf_efs.c wsf_heap_sbrk.c wsf_msg.c wsf_nvm.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/wspc/: wspc_main.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/Cordio/ble-profiles/sources/profiles/wsps/: wsps_main.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/WUT/: wut_me18.c wut_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me18.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Low Power_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/LP/: lp_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/ICC/: icc_me18.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CTB_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/CTB/: ctb_common.c ctb_me18.c ctb_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me18.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.0.1
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.1}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me18.c i2c_reva.c
