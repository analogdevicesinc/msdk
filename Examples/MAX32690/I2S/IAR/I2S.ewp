# IAR project I2S.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32690; TARGET_REV=0X4131; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: I2S.srec
  ILINK.IlinkOutputFile: I2S.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$\.iar\config\linker\MAX32690_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me18.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me18.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.0.0
    ../RTE/Device/MAX32690_Cortex-M4/: cmain.s heap.c low_level_init.c max32690.h startup_max32690.s system_max32690.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me18.c uart_revb.c
  group CMSIS-Pack/Maxim MAX32690 BSP _BSP.EvKit V1_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/Boards/MAX32690/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/Boards/MAX32690/Source/: led.c pb.c stdio.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me18.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me18.c sys_me18.c
  group CMSIS-Pack/Maxim Maxim API _Device.Timers_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me18.c tmr_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.CTB_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/CTB/: ctb_common.c ctb_me18.c ctb_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2S_1.0.0
    ${CMSIS_PACK_PATH_Maxim#MAX32690#1.0.0}$/Libraries/PeriphDrivers/Source/I2S/: i2s_me18.c i2s_reva.c
