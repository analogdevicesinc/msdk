# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32665; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$.iar\config\linker\MAX32665_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.Board Type.EvKit_V1_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/Boards/MAX32665/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/MiscDrivers/: stdio.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.ExtMemory.MX25_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.LED.LED_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/MiscDrivers/LED/: led.c
  group CMSIS-Pack/Maxim MAX32665 BSP _BSP.PushButton.PB_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/MiscDrivers/PushButton/: pb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WUT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/WUT/: wut_me14.c wut_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_common.c wdt_me14.c wdt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me14.c uart_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me14.c trng_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.TPU_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/TPU/: tpu_me14.c tpu_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me14.c tmr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SRCC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SRCC/: srcc_me14.c srcc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SPIXR/: spixr_me14.c spixr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXF_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SPIXF/: spixf_me14.c spixf_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me14.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.SIMO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SIMO/: simo_me14.c simo_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SEMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SEMA/: sema_me14.c sema_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SDHC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SDHC/: sdhc_me14.c sdhc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me14.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RPU_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/RPU/: rpu_me14.c rpu_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/PT/: pt_me14.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_me14.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me14.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_me14.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me14.c i2c_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.HTMR_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/HTMR/: htmr_me14.c htmr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me14.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me14.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me14.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CORE1_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/CORE1/: system_core1.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me14.c adc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.2.0
    ${CMSIS_PACK_PATH_Maxim#MAX32665#1.2.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me14.c sys_me14.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.2.0
    ../RTE/Device/MAX32665_Cortex-M4/: cmain.s low_level_init.c max32665.h startup_max32665.s system_max32665.c
