# Keil uVision project Hello_World.uvprojx, settings and files
target Flash Debug (6160000::V6.16::ARMCLANG)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.1.2.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Hello_World +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32665 TARGET_REV=0x4131 EXT_FLASH_MX25
  c include: ..\..\Hello_World;\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Hello_World.sct
  group Source
    ../: main.c
software components: CMSIS:CORE 5.3.0, BSP:Board Type 1.2.0, BSP:ExtMemory 1.2.0, BSP:LED 1.2.0, BSP:PushButton 1.2.0, Device:ADC 1.2.0, Device:CORE1 1.2.0, Device:DMA 1.2.0, Device:FLC 1.2.0, Device:GPIO 1.2.0, Device:HTMR 1.2.0, Device:I2C 1.2.0, Device:ICC 1.2.0, Device:LP 1.2.0, Device:OWM 1.2.0, Device:PT 1.2.0, Device:RPU 1.2.0, Device:RTC 1.2.0, Device:SDHC 1.2.0, Device:SEMA 1.2.0, Device:SIMO 1.2.0, Device:SPI 1.2.0, Device:SPIXF 1.2.0, Device:SPIXR 1.2.0, Device:SRCC 1.2.0, Device:SYS 1.2.0, Device:Startup 1.2.0, Device:TMR 1.2.0, Device:TPU 1.2.0, Device:TRNG 1.2.0, Device:UART 1.2.0, Device:WDT 1.2.0, Device:WUT 1.2.0
