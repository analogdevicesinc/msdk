# Keil uVision project Hello_World.uvprojx, settings and files
target Flash Debug (6180000::V6.18::ARMCLANG)
  device: MAX32650:Cortex-M4 Maxim
  pack: Maxim.MAX32650.1.3.0
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: Hello_World +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: TARGET=32650 TARGET_REV=0x4131 EXT_FLASH_MX25
  c include: ..\..\Hello_World;\ARM;..\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Hello_World.sct
  group Source
    ../: main.c
software components: CMSIS:CORE 5.3.0, BSP:Board Type 1.3.0, BSP:ExtMemory 1.3.0, BSP:LED 1.3.0, BSP:PushButton 1.3.0, Device:ADC 1.3.0, Device:CLCD 1.3.0, Device:DMA 1.3.0, Device:EMCC 1.3.0, Device:FLC 1.3.0, Device:GPIO 1.3.0, Device:HPB 1.3.0, Device:I2C 1.3.0, Device:ICC 1.3.0, Device:LP 1.3.0, Device:OWM 1.3.0, Device:PT 1.3.0, Device:RTC 1.3.0, Device:SDHC 1.3.0, Device:SEMA 1.3.0, Device:SPI 1.3.0, Device:SPIMSS 1.3.0, Device:SPIXF 1.3.0, Device:SPIXR 1.3.0, Device:SRCC 1.3.0, Device:SYS 1.3.0, Device:Startup 1.3.0, Device:TMR 1.3.0, Device:TPU 1.3.0, Device:TRNG 1.3.0, Device:UART 1.3.0, Device:WDT 1.3.0
