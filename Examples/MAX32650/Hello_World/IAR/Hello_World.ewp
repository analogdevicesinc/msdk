# IAR project Hello_World.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET=32650; TARGET_REV=0x4131; EXT_FLASH_MX25; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; ..; ..\RTE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Hello_World.srec
  ILINK.IlinkOutputFile: Hello_World.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$.iar\config\linker\MAX32650_IAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCOptLevel: 3
  group (top)
    ../: main.c
  group CMSIS-Pack
    ../RTE/: RTE_Components.h
  group CMSIS-Pack/Maxim MAX32650 BSP _BSP.ExtMemory.MX25_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/MiscDrivers/ExtMemory/: mx25.c
  group CMSIS-Pack/Maxim MAX32650 BSP _BSP.Board Type.EvKit_V1_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/Boards/MAX32650/EvKit_V1/Source/: board.c
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/MiscDrivers/: stdio.c
  group CMSIS-Pack/Maxim MAX32650 BSP _BSP.LED.LED_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/MiscDrivers/LED/: led.c
  group CMSIS-Pack/Maxim MAX32650 BSP _BSP.PushButton.PB_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/MiscDrivers/PushButton/: pb.c
  group CMSIS-Pack/Maxim Maxim API _Device.WDT_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/WDT/: wdt_me10.c wdt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.UART_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/UART/: uart_common.c uart_me10.c uart_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TRNG_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/TRNG/: trng_me10.c trng_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TPU_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/TPU/: tpu_me10.c tpu_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.TMR_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/TMR/: tmr_common.c tmr_me10.c tmr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXR_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SPIXR/: spixr_me10.c spixr_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIXF_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SPIXF/: spixf_me10.c spixf_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPIMSS_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SPIMSS/: i2s_me10.c i2s_reva.c spimss_me10.c spimss_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SPI_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SPI/: spi_me10.c spi_reva1.c
  group CMSIS-Pack/Maxim Maxim API _Device.SEMA_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SEMA/: sema_me10.c sema_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SDHC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SDHC/: sdhc_me10.c sdhc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.RTC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/RTC/: rtc_me10.c rtc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.PT_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/PT/: pt_me10.c pt_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.OWM_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/OWM/: owm_me10.c owm_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.LP_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/LP/: lp_me10.c
  group CMSIS-Pack/Maxim Maxim API _Device.ICC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/ICC/: icc_common.c icc_me10.c icc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.I2C_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/I2C/: i2c_me10.c i2c_reva.c i2c_revb.c
  group CMSIS-Pack/Maxim Maxim API _Device.HPB_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/HPB/: hpb_me10.c hpb_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.GPIO_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/GPIO/: gpio_common.c gpio_me10.c gpio_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.FLC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/FLC/: flc_common.c flc_me10.c flc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SRCC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SRCC/: srcc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.EMCC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/EMCC/: emcc_me10.c
  group CMSIS-Pack/Maxim Maxim API _Device.DMA_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/DMA/: dma_me10.c dma_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.CLCD_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/CLCD/: clcd_me10.c clcd_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.ADC_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/ADC/: adc_me10.c adc_reva.c
  group CMSIS-Pack/Maxim Maxim API _Device.SYS_1.3.0
    ${CMSIS_PACK_PATH_Maxim#MAX32650#1.3.0}$/Libraries/PeriphDrivers/Source/SYS/: mxc_assert.c mxc_delay.c mxc_lock.c nvic_table.c pins_me10.c sys_me10.c
  group CMSIS-Pack/Maxim Maxim API _Device.Startup_1.3.0
    ../RTE/Device/MAX32650_Cortex-M4/: cmain.s low_level_init.c max32650.h startup_max32650.s system_max32650.c
